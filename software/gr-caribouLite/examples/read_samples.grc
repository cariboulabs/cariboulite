options:
  parameters:
    author: Alon and David
    generate_options: qt_gui
    id: cariboulite_source_test
    output_language: python
  states: {}

blocks:
- name: caribouLite_caribouLiteSource_0
  id: caribouLite_caribouLiteSource
  parameters:
    channel: '0'
    enable_agc: 'False'
    freq: '900000000.0'
    rx_bw: '2500000.0'
    rx_gain: '40.0'
    sample_rate: '4000000.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 4e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [caribouLite_caribouLiteSource_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-604-gd7f88722
