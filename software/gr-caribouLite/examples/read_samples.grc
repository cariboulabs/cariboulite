options:
  parameters:
    author: Alon and David
    generate_options: no_gui
    id: cariboulite_source_test
    output_language: cpp
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: caribouLite_caribouLiteSource_0
  id: caribouLite_caribouLiteSource
  parameters:
    channel: '0'
    enable_agc: 'False'
    freq: '900000000.0'
    rx_bw: '2500000.0'
    rx_gain: '40.0'
    sample_rate: '4000000.0'
  states: {}

connections:
- [caribouLite_caribouLiteSource_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-604-gd7f88722
