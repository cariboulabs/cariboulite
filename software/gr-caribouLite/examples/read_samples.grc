options:
  parameters:
    author: Alon and David
    generate_options: no_gui
    id: cariboulite_source_test
    output_language: cpp
  states: {}

blocks:
- name: caribouLite_caribouLiteSource_0
  id: caribouLite_caribouLiteSource
  parameters:
    channel: '0'
    enable_agc: 'True'
    freq: '905000000.0'
    rx_bw: '2000000.0'
    rx_gain: '40.0'
    sample_rate: '4000000.0'
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: '500000'
    center_freq: '0'
    impl_head: 'True'
    os_factor: '4'
    preamb_len: '8'
    sf: '5'
    show_log_port: 'True'
    sync_word: '18'
  states: {}

connections:
- [caribouLite_caribouLiteSource_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-604-gd7f88722
